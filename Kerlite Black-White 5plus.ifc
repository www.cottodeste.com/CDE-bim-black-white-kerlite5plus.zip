Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement[Architecture]
File name: F:/BIM PGR/BIM COTTO D'ESTE/Black - White/Kerlite Black-White 5plus.ifc
Time: 2021-01-29T11:06:46
Author: Architect
Organization: Nemetschek Vectorworks, Inc.
Written by: Vectorworks Architect 2021 SP2 R1 (Build 574483) (64-Bit) by Vectorworks, Inc.
Made in: Windows

# IfcSite, Sito standard
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0

# IfcBuilding, Edificio standard
Pset_BuildingCommon - SprinklerProtection: no; SprinklerProtectionAutomatic: no; NumberOfStoreys: 1; IsLandmarked: no

# IfcBuildingStorey, Piano 1
In: Edificio standard
Elevation: 0 mm
Pset_BuildingStoreyCommon - EntranceLevel: no; AboveGround: yes; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2

# IfcCovering: Laminated porcelain stoneware (UGL) (12)
In: Piano 1
Description: Porcelain stoneware tiles; PredefinedType: USERDEFINED; Material: Default
OtherThecnicalFeatures - AntibacterialProperties: Protect - test report available; ApparentDensity: 2,3 - 2,5 g/cm3; CompressionResistance: n/a; CrazingResistance: Pass; DeepAbrasionResistance: 175mm3; DimensionsLengthAndWidth: ± 0,3 %, max ± 1 mm; DimensionsRectangularity: ± 0,3 %, max ± 1,5 mm; DimensionsStraightness: ± 0,3 %, max ± 0,8 mm; DimensionsSurfaceFlatness: ± 0,4 %, max ± 1,8 mm; DimensionsThickness: ± 5 % ± 0,5mm; ElectricalConductivity: n/a; FrostResistance: Resistant; HardnessMohsScale: n/a; ImpactResistance: n/a; Light ReflectanceValueLRV: On request; LightAndColourFastness: Pass; LinearThermalExpansion: α ≤ 7·10-6 °C-1; ModulusOfRupture: 50 N/mm2; MoistureExpansion: n/a; PhotocatalyticProperties: n/a; SurfaceAbrasionResistance: n/a; SurfaceQuality: n/a; ThermalConductivity: 1,3 W/m °K; TotalPorosity: n/a; WaterAbsorption: 0,1%
EnvironmentalSustainability - AsbestosFreeMaterial: yes; CAMCompliantDeclaration: On request (EPD); Ecolabel UE: no; EcolabelCertification: n/a; EMASCertification/Document: https://www.cottodeste.it/download#certificazioni; EnvironmentalProductDeclarationEPD: yes; EPDDocument: On request; EPDType: Product-Specific Type III EPD; FicheDeDéclarationEnvironnementaleEtSanitaireFDESCertification: n/a; FormaldehydeFreeMaterial: yes; HealthProductDeclarationHPDCertification/self declaration: On request; ISO45001Certification: n/a; ISO50001Certification: n/a; ISO9001Certification: https://www.cottodeste.it/download#certificazioni; RawMaterialSourceAndExtractionDocument: On request; REACHCompliant: yes; RecyclableProductPackaging: yes; RecycledContentPreconsumerCertification: https://www.cottodeste.it/download#certificazioni; SolarReflectance_After3YearValue: On request; SolarReflectance_InitialValue: On request; SolarReflectanceCertification: n/a; SolarReflectanceIndexSRICertification: On request; VOCIndoorAirQualityCertification: On request; ZeroVOCMineralBasedProduct: yes
DoP&ProductCertification - BondStrengthAdhesion: NPD; BreakingStrength: ≥ 700 N; CEMarking: yes; CertificateNumber: n/a; DeclarationPerformanceNumber: DOP005EST; DurabilityExternalUseFreezeThawResistance: Passed; DurabilityForInternalUse: Passed; HarmonizedTechnicalSpecification: EN 14411:2012; Intended Use: Ceramic tiles for internal flooring and internal and external wall applications, pre-assembled on a fibreglass mesh.; NameAndIdentificationNumberOfNotifiedLaboratory: n/a; ReactionToFire: A2fl-s1/A1-s1,d0; ReleaseOfDangerousSubstanceCadmium: NPD; ReleaseOfDangerousSubstanceLead: NPD; SlipperinessBCRA_Tribometer: n/a; SlipperinessBOT3000_Tribometer: n/a; SlipperinessBS7976-2_PendulumTester: n/a; SlipperinessDIN51097_RampBarefoot: n/a; SlipperinessDIN51130_RampWithOil: n/a; SlipperinessDIN51131_Tribometer: n/a; SlipperinessENV12633_PendulumTester: n/a; SlipperinessXPCENTS16165_RampTest: n/a; SystemOfAssessmentAndVerificationOfCostancyOfPperformance: System 4; Tactility: NPD; TensileStrengthOrModulusOfRupture: 50 N/mm2; ThermalShockResistance: Pass; UNIMark: no; UNIMarkCertification: On request; UniqueIdentificationCodeOfTheProductType: Dry-pressed ceramic tiles,with water absorption Eb<0,5%
COBie_ServiceLife - ExpectedLife: 50
COBie_EconomicImpactValues - ReplacementCost: 0
COBie_Component - InstallationDate: 31/12/1900 23:59:59; WarrantyStartDate: n/a; TagNumber: n/a; AssetIdentifier: n/a
Pset_CoveringFlooring - HasNonSkidSurface: yes; HasAntiStaticSurface: no
Pset_Condition - AssessmentDate: 31/12/1900 23:59:59; AssessmentCondition: n/a; AssessmentDescription: n/a
Pset_CoveringCommon - Reference: Laminated porcelain stoneware (UGL); AcousticRating: n/a; FlammabilityRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor); FragilityRating: n/a; Combustible: no; SurfaceSpreadOfFlame: Class A; IsExternal: no; ThermalTransmittance: 236 W/K/m2; FireRating: Class A2-s1, do (wall) ; Class A2fl-s1 (floor)
COBie_Asset - AssetType: Fixed
COBie_Specification - NominalWidth: 1000 mm; NominalHeight: 5.5 mm; Grade: n/a; Material: Porcelain stoneware tile; Constituents: n/a; Features: n/a; AccessibilityPerformance: n/a; CodePerformance: n/a; SustainabilityPerformance: n/a
COBie_Warranty - WarrantyGuarantorParts: n/a; WarrantyDurationParts: 0; WarrantyGuarantorLabor: n/a; WarrantyDurationLabor: 0; WarrantyDescription: n/a
Pset_ManufacturerTypeInformation - GlobalTradeItemNumber: n/a; ModelReference: Kerlite Black & White 5plus; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ProductionYear: n/a
Pset_EnvironmentalImpactIndicators - Reference: Laminated porcelain stoneware (UGL); FunctionalUnitReference: 1 mq (m2); Unit: 1 mq (m2); LifeCyclePhase: Manufacture; ExpectedServiceLife: 50 s; TotalPrimaryEnergyConsumptionPerUnit: 225; WaterConsumptionPerUnit: 0.054 m3; HazardousWastePerUnit: 0.00235 g; NonHazardousWastePerUnit: 1.62 g; ClimateChangePerUnit: 10.7 g; AtmosphericAcidificationPerUnit: 0.0254 g; RenewableEnergyConsumptionPerUnit: 46; NonRenewableEnergyConsumptionPerUnit: 179; ResourceDepletionPerUnit: 0.000075 g; InertWastePerUnit: 0 g; RadioactiveWastePerUnit: 0.00393 g; StratosphericOzoneLayerDestructionPerUnit: 0 g; PhotochemicalOzoneFormationPerUnit: 0.00232 g; EutrophicationPerUnit: 0.00358 g
Pset_EnvironmentalImpactValues - TotalPrimaryEnergyConsumption: 0; WaterConsumption: 0 m3; HazardousWaste: 0 g; NonHazardousWaste: 0 g; ClimateChange: 0 g; AtmosphericAcidification: 0 g; RenewableEnergyConsumption: 0; NonRenewableEnergyConsumption: 0; ResourceDepletion: 0 g; InertWaste: 0 g; RadioactiveWaste: 0 g; StratosphericOzoneLayerDestruction: 0 g; PhotochemicalOzoneFormation: 0 g; Eutrophication: 0 g; LeadInTime: 0; Duration: 0; LeadOutTime: 0
Pset_ServiceLife - ServiceLifeDuration: 50; MeanTimeBetweenFailure: n/a
Pset_Warranty - WarrantyIdentifier: n/a; WarrantyStartDate: 31/12/1900 23:59:59; WarrantyEndDate: 31/12/1900 23:59:59; IsExtendedWarranty: no; WarrantyPeriod: n/a; WarrantyContent: n/a; PointOfContact: n/a; Exclusions: n/a
COBie - BarCode: n/a; Category: Pr_35_93_96_19:Ceramic tiles; Description: Color Effect; DurationUnit: Year; Manufacturer: Cotto d'Este (Panariagroup Industrie Ceramiche S.p.A.); ModelNumber: n/a; ModelReference: Kerlite Black & White 5plus; SerialNumber: n/a; WarrantyDurationUnit: Year
Name | ChemicalResistance | StainsResistance | UPECmark | UPECMarkCertification | Pset_CoveringCommon, Finish = COBie_Specification, Finish | NominalLength (mm) | Shape | Size | Color | ArticleNumber | ModelLabel | Name
Kerlite Black & White 5plus Ultrawhite Silk Ret 100x300 | LA, HA RESISTANT | 5 RESISTANT | no | n/a | Silk Rectified | 3000 | Rectangular | 3000x1000x5.5 mm | Ultrawhite | EK7KB65 | Ultrawhite Silk | Ultrawhite Silk Rettificato 100x300
Kerlite Black & White 5plus Ultrawhite Silk Ret 100x100 | LA, HA RESISTANT | 5 RESISTANT | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Silk Rectified | 1000 | Square | 1000x1000x5.5 mm | Ultrawhite | EK8KB20 | Ultrawhite Silk | Ultrawhite Silk Rettificato 100x100
Kerlite Black & White 5plus Ultrawhite Silk Ret 50x100 | LA, HA RESISTANT | 5 RESISTANT | no | n/a | Silk Rectified | 500 | Rectangular | 500x1000x5.5 mm | Ultrawhite | EK9KB61 | Ultrawhite Silk | Ultrawhite Silk Rettificato 50x100
Kerlite Black & White 5plus Ultrawhite Glossy Ret 100x300 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 3000 | Rectangular | 3000x1000x5.5 mm | Ultrawhite | EK7KB60 | Ultrawhite Glossy | Ultrawhite Glossy Rettificato 100x300
Kerlite Black & White 5plus Ultrawhite Glossy Ret 100x100 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 1000 | Square | 1000x1000x5.5 mm | Ultrawhite | EK8KB60 | Ultrawhite Glossy | Ultrawhite Glossy Rettificato 100x100
Kerlite Black & White 5plus Ultrawhite Glossy Ret 50x100 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 500 | Rectangular | 500x1000x5.5 mm | Ultrawhite | EK9KB60 | Ultrawhite Glossy | Ultrawhite Glossy Rettificato 50x100
Kerlite Black & White 5plus Black Silk Ret 100x300 | LA, HA RESISTANT | 5 RESISTANT | no | n/a | Silk Rectified | 3000 | Rectangular | 3000x1000x5.5 mm | Black | EK7KB75 | Black Silk | Black Silk Rettificato 100x300
Kerlite Black & White 5plus Black Silk Ret 100x100 | LA, HA RESISTANT | 5 RESISTANT | yes | http://webapp.cstb.fr/upec-ceramique/index.php?view=TitulaireListeProduits&sid=42&tid=1 | Silk Rectified | 1000 | Square | 1000x1000x5.5 mm | Black | EK8KB30 | Black Silk | Black Silk Rettificato 100x100
Kerlite Black & White 5plus Black Silk Ret 50x100 | LA, HA RESISTANT | 5 RESISTANT | no | n/a | Silk Rectified | 500 | Rectangular | 500x1000x5.5 mm | Black | EK9KB71 | Black Silk | Black Silk Rettificato 50x100
Kerlite Black & White 5plus Black Glossy Ret 100x300 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 3000 | Rectangular | 3000x1000x5.5 mm | Black | EK7KB70 | Black Glossy | Black Glossy Rettificato 100x300
Kerlite Black & White 5plus Black Glossy Ret 100x100 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 1000 | Square | 1000x1000x5.5 mm | Black | EK8KB70 | Black Glossy | Black Glossy Rettificato 100x100
Kerlite Black & White 5plus Black Glossy Ret 50x100 | LB, HB | ≥ 3 | no | n/a | Glossy Rectified | 500 | Rectangular | 500x1000x5.5 mm | Black | EK9KB70 | Black Glossy | Black Glossy Rettificato 50x100
